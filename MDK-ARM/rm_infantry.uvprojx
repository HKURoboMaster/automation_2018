# Keil uVision project rm_infantry.uvprojx, settings and files
target rm_infantry (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: rm_infantry +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,ARM_MATH_CM4,__FPU_PRESENT
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src/drivers;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;.\app;.\bsp;.\rmlib;.\other_lib;..\Drivers\CMSIS\Device
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
    ../Drivers/CMSIS/Device/: arm_mat_add_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash.c stm32f4xx_hal_cortex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c tasks.c event_groups.c timers.c queue.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User
    ../Src/: gpio.c bsp_driver_sd.c dma.c tim.c usart.c stm32f4xx_hal_msp.c stm32f4xx_it.c sdio.c freertos.c can.c main.c stm32f4xx_hal_timebase_TIM.c rtc.c spi.c fatfs.c
  group Application/UserBsp
    ./bsp/: bsp_can.c bsp_uart.c bsp_imu.c bsp_flash.c bsp_io.c
    ./app/: cpu_utils.c
  group Application/Interactive
    ./app/: info_interactive.c
  group Application/AppCtrl
    ./app/: gimbal_task.c chassis_task.c shoot_task.c sys_config.h
  group Application/ModeSw
    ./app/: modeswitch_task.c
  group Application/AppInfo
    ./app/: info_get_task.c imu_task.c detect_task.c record_task.c
    ./: RobotType.h
  group Application/Comm
    ./app/: comm_task.c
    ./rmlib/: communicate.c
  group Application/Protocol
    ./rmlib/: infantry_info.c judgement_info.c protocol.c
  group Application/RmLib
    ./rmlib/: ramp.c pid.c calibrate.c keyboard.c remote_ctrl.c kalman_filter.c
    ./other_lib/: data_fifo.c
  group Doc
    ../Doc/: read_me.txt
